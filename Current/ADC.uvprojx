# Keil uVision project ADC.uvprojx, settings and files
target ADC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Application;.\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries/CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries/StdPeriph_Driver_v3.5.0
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_tim.c
  group Driver
    ./Driver/: Gpio.c delay.c USART.c ADC.c SDS.c fsmc_sram.c Timer.c WB_LCD.c font.h HZ.h WB_LCD.h
  group Application
    ./Application/: main.c stm32f10x_it.c stm32f10x_it.h table_fft.h stm32_dsp.h ForNonSin50Hz_200Hz.c ForSin50Hz_1KHz.c Other.c Config.h Function.c
  group Doc
    ./Doc/: readme.txt
  group Libraries/DSP
    ./Libraries/STM32F10x_DSP_Lib/src/: iir_stm32.c
    ./Libraries/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s
